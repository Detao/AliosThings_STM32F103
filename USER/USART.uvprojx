# Keil uVision project USART.uvprojx, settings and files
target USART (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AliosThings +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,WITH_SAL,CONFIG_AOS_CLI
  c misc: -DSYSINFO_KERNEL_VERSION=\"AOS-1.3.2\" -DSYSINFO_DEVICE_NAME=\"STM32F103\"
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\AliOS-Things-master\include;..\AliOS-Things-master\kernel\rhino\core\include;..\AliOS-Things-master\platform\arch\arm\armv7m\armcc\m3;..\AliOS-Things-master\utility\libc\compilers\armlibc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group AOSAPI
    ../AliOS-Things-master/kernel/vcall/aos/: aos_rhino.c
  group RHINO
    ../AliOS-Things-master/kernel/rhino/core/: k_workqueue.c k_timer.c k_time.c k_tick.c k_task_sem.c k_task.c k_sys.c k_stats.c k_sem.c k_sched.c k_ringbuf.c k_queue.c k_pend.c k_obj.c k_mutex.c k_mm_debug.c k_mm_blk.c k_mm.c k_idle.c k_event.c k_err.c k_dyn_mem_proc.c k_buf_queue.c
  group PORT
    ../AliOS-Things-master/platform/arch/arm/armv7m/armcc/m3/: port_c.c port_s.s
  group README
    ../: README.md
  group SOC_INIT
    ../AliOS-Things-master/platform/mcu/stm32f103/aos/: soc_impl.c soc_init.c aos.c
  group CLI
    ../AliOS-Things-master/tools/cli/: dumpsys.c cli.c
  group LOG
    ../AliOS-Things-master/utility/log/: log.c
  group HAL
    ../AliOS-Things-master/platform/mcu/stm32f103/hal/: hal_uart_stm32.c
