# IAR project STM32L496AGIx.ewp, settings and files
configuration STM32L496AGIx (ARM, debug)
  General.OGChipSelectEditMenu: STM32L496AG ST STM32L496AG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L496xx; SYSINFO_OS_VERSION="APP-1.0.0"; SYSINFO_PRODUCT_MODEL="ALI_AOS_STM32L496AGIx"; SYSINFO_DEVICE_NAME="STM32L496AGIx"; SYSINFO_KERNEL_VERSION="AOS-R-1.3.0"; SYSINFO_APP_VERSION="APP-1.0.0"; STDIO_UART=0; CONFIG_NO_TCPIP; _TIMESPEC_DEFINED; RHINO_CONFIG_TICK_TASK=0; CONFIG_AOS_KV_MULTIPTN_MODE; CONFIG_AOS_KV_PTN=6; CONFIG_AOS_KV_SECOND_PTN=7; CONFIG_AOS_KV_PTN_SIZE=4096; CONFIG_AOS_KV_BUFFER_SIZE=8192; AOS_KV; __BSD_VISIBLE
  ICCARM.CCIncludePath2: ..\..\..\..\include; ..\..\..\..\kernel\rhino\core\include; ..\..\..\..\platform\arch\arm\armv7m\iccarm\m4; ..\..\..\..\platform\mcu\stm32l4xx\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\platform\mcu\stm32l4xx\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\platform\mcu\stm32l4xx\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\platform\mcu\stm32l4xx\Drivers\CMSIS\Include; ..\..\..\..\platform\mcu\stm32l4xx\src\STM32L496G-Discovery\aos_rhino; ..\..\..\..\include\hal; ..\..\..\..\kernel\vcall\aos; ..\..\..\..\utility\libc\compilers\iar; ..\..\..\..\board\stm32l496g-discovery; ..\..\..\..\kernel\modules\fs\kv\include; ..\..\..\..\include\hal\soc; ..\..\..\..\kernel\vfs\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L496AGIx.srec
  ILINK.IlinkOutputFile: STM32L496AGIx.out
  ILINK.IlinkIcfFile: stm32l496xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group AOS/Arch
    ../../../../platform/arch/arm/armv7m/iccarm/m4/: port_c.c port_s.S
  group AOS/fs\kv
    ../../../../kernel/modules/fs/kv/: kvmgr.c
  group AOS/Kernel
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group AOS/Libc
    ../../../../utility/libc/compilers/iar/: iar_libc.c
  group Application
    ../../../../platform/mcu/stm32l4xx/src/STM32L496G-Discovery/aos_rhino/: aos_rhino_kv.c soc_init.c stm32l4xx_hal_msp.c stm32l4xx_it.c
    ../../../../board/stm32l496g-discovery/aos/: board_partition.c
    ../../../../platform/mcu/stm32l4xx/aos/: soc_impl.c
  group Drivers/BSP
    ../../../../platform/mcu/stm32l4xx/Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../platform/mcu/stm32l4xx/Drivers/BSP/STM32L496G-Discovery/: stm32l496g_discovery.c stm32l496g_discovery_io.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../platform/mcu/stm32l4xx/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/SYSTEM
    ../../../../platform/mcu/stm32l4xx/src/STM32L496G-Discovery/: startup_stm32l496xx_iar.s
    ../../../../platform/mcu/stm32l4xx/src/STM32L496G-Discovery/aos_rhino/: system_stm32l4xx.c
  group Example
    ../../../../example/rhinorun/: rhinorun.c
  group HAL
    ../../../../platform/mcu/stm32l4xx/src/STM32L496G-Discovery/hal/: flash_l4.c flash_port.c
